# Keil uVision project A_i2s_capture.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: R7FA6M5BF Renesas
  pack: Renesas.RA_DFP.6.3.0
  cpu: IRAM(0x20000000,0x080000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: A_i2s_capture
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3
  c define: ARM_MATH_CM33 TFLITE_SINGLE_ROUNDING
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  c include: d:/keil_v5/keil/tensorflow/third_party/flatbuffers;d:/keil_v5/keil/tensorflow/third_party/kissfft;d:/keil_v5/keil/tensorflow/third_party/kissfft/tools;d:/keil_v5/keil/tensorflow/third_party/tflite-micro;d:/keil_v5/keil/tensorflow/third_party
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group Source Group 1
    ./src/: quantized_multiplier_stub.cpp error_reporter_stub.cpp digit_model.c digit_recognizer.cpp
    ../../tensorflow/tensorflow-lite-micro/1.25.2/tensorflow/lite/core/c/: common.cpp
    ./src/drivers/: drv_lcd.c drv_spi0_manual.c drv_touch.c
    ./src/ui/: lcd_draw.c ui_state_machine.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c audio_capture.c audio_features.c audio_capture.h audio_features.h
    ./src/net/: cloud_asr_client.c cloud_speaker_client.c w800_at.c cloud_asr_cfg.h cloud_asr_client.h cloud_speaker_cfg.h cloud_speaker_client.h w800_at.h
  group MVP W800
    ./src/mvp/: app_main.c cloud_speaker_demo_client.c cloud_http_client.c http_parser_lite.c log.c test_audio_data.c uart_ringbuf.c w800_at.c w800_socket.c w800_wifi.c wav_pack.c
  group TFLM Core Engine
    d:/keil_v5/keil/tensorflow/tensorflow-lite-micro/1.25.2/tensorflow/compiler/mlir/lite/schema/: schema_utils.cpp
    d:/keil_v5/keil/tensorflow/tensorflow-lite-micro/1.25.2/tensorflow/lite/micro/kernels/: kernel_util.cpp activations.cpp activations_common.cpp add.cpp add_common.cpp add_n.cpp arg_min_max.cpp assign_variable.cpp batch_matmul.cpp batch_matmul_common.cpp batch_to_space_nd.cpp broadcast_args.cpp broadcast_to.cpp call_once.cpp cast.cpp ceil.cpp circular_buffer.cpp circular_buffer_common.cpp concatenation.cpp conv.cpp conv_common.cpp cumsum.cpp decompress.cpp decompress_common.cpp depthwise_conv.cpp depthwise_conv_common.cpp depth_to_space.cpp dequantize.cpp dequantize_common.cpp detection_postprocess.cpp div.cpp elementwise.cpp elu.cpp embedding_lookup.cpp exp.cpp expand_dims.cpp fill.cpp floor.cpp floor_div.cpp floor_mod.cpp fully_connected.cpp fully_connected_common.cpp gather.cpp gather_nd.cpp hard_swish.cpp hard_swish_common.cpp if.cpp l2norm.cpp l2_pool_2d.cpp leaky_relu.cpp leaky_relu_common.cpp logical.cpp logical_common.cpp logistic.cpp logistic_common.cpp log_softmax.cpp lstm_eval.cpp lstm_eval_common.cpp maximum_minimum.cpp micro_tensor_utils.cpp mirror_pad.cpp mul.cpp mul_common.cpp neg.cpp pack.cpp pad.cpp pooling.cpp pooling_common.cpp prelu.cpp prelu_common.cpp quantize.cpp quantize_common.cpp read_variable.cpp reduce.cpp reduce_common.cpp reshape.cpp reshape_common.cpp resize_bilinear.cpp resize_nearest_neighbor.cpp round.cpp select.cpp shape.cpp slice.cpp softmax.cpp softmax_common.cpp space_to_batch_nd.cpp space_to_depth.cpp split.cpp split_v.cpp squared_difference.cpp squeeze.cpp strided_slice.cpp strided_slice_common.cpp sub.cpp sub_common.cpp svdf.cpp svdf_common.cpp tanh.cpp transpose.cpp transpose_conv.cpp unidirectional_sequence_lstm.cpp unpack.cpp var_handle.cpp while.cpp zeros_like.cpp
    d:/keil_v5/keil/tensorflow/tensorflow-lite-micro/1.25.2/tensorflow/lite/core/api/: flatbuffer_conversions.cpp tensor_utils.cpp
    d:/keil_v5/keil/tensorflow/tensorflow-lite-micro/1.25.2/tensorflow/lite/kernels/internal/: portable_tensor_utils.cpp quantization_util.cpp runtime_shape.cpp tensor_ctypes.cpp
    d:/keil_v5/keil/tensorflow/tensorflow-lite-micro/1.25.2/tensorflow/lite/kernels/internal/reference/: comparisons.cpp
    d:/keil_v5/keil/tensorflow/tensorflow-lite-micro/1.25.2/tensorflow/lite/micro/: fake_micro_context.cpp flatbuffer_utils.cpp memory_helpers.cpp micro_allocation_info.cpp micro_allocator.cpp micro_context.cpp micro_interpreter.cpp micro_interpreter_context.cpp micro_interpreter_graph.cpp micro_log.cpp micro_op_resolver.cpp micro_profiler.cpp micro_resource_variable.cpp micro_utils.cpp recording_micro_allocator.cpp
    d:/keil_v5/keil/tensorflow/tensorflow-lite-micro/1.25.2/tensorflow/lite/micro/arena_allocator/: non_persistent_arena_buffer_allocator.cpp persistent_arena_buffer_allocator.cpp recording_single_arena_buffer_allocator.cpp single_arena_buffer_allocator.cpp
    d:/keil_v5/keil/tensorflow/tensorflow-lite-micro/1.25.2/tensorflow/lite/micro/memory_planner/: greedy_memory_planner.cpp linear_memory_planner.cpp non_persistent_buffer_planner_shim.cpp
    d:/keil_v5/keil/tensorflow/tensorflow-lite-micro/1.25.2/tensorflow/lite/micro/tflite_bridge/: flatbuffer_conversions_bridge.cpp micro_error_reporter.cpp
software components: CMSIS:CORE 6.2.0, Flex Software:RA Configuration 1.0.0
