# Keil uVision project A_i2s_capture_prebuilt.uvprojx, settings and files
target Target 1 (Prebuilt Libs) (6240000::V6.24::ARMCLANG)
  device: R7FA6M5BF Renesas
  pack: Renesas.RA_DFP.6.3.0
  cpu: IRAM(0x20000000,0x080000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: A_i2s_capture_prebuilt
  BeforeMake: powershell.exe -ExecutionPolicy Bypass -File ".\tools\build_prebuilt_libs.ps1"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3
  c define: ARM_MATH_CM33 TFLITE_SINGLE_ROUNDING
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal -include ./RTE/_Target_1/Pre_Include_Global.h -include ./RTE/_Target_1/RTE_Components.h
  c include: d:/keil_v5/keil/tensorflow/third_party/flatbuffers;d:/keil_v5/keil/tensorflow/third_party/kissfft;d:/keil_v5/keil/tensorflow/third_party/kissfft/tools;d:/keil_v5/keil/tensorflow/third_party/tflite-micro;d:/keil_v5/keil/tensorflow/third_party;d:/keil_v5/keil/ARM/CMSIS-DSP/1.17.0/Include;d:/keil_v5/keil/ARM/CMSIS-DSP/1.17.0/PrivateInclude;d:/keil_v5/keil/ARM/CMSIS-NN/7.0.0/Include;d:/keil_v5/keil/tensorflow/tensorflow-lite-micro/1.25.2;d:/keil_v5/keil/tensorflow/tensorflow-lite-micro/1.25.2/tensorflow/lite/micro/testing;./RTE/_Target_1;./ra/arm/CMSIS_6/CMSIS/Core/Include;./ra/fsp/inc;./ra/fsp/inc/api;./ra/fsp/inc/instances;./ra_cfg/fsp_cfg;./ra_cfg/fsp_cfg/bsp;./ra_gen;./src;./src/drivers;./src/ui;./src/net;./ra/fsp/src/bsp/mcu/all;./ra/fsp/src/bsp/mcu/ra6m5;./ra/fsp/src/bsp/cmsis/Device/RENESAS
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via" ".\prebuilt\lib\tflm.lib" ".\prebuilt\lib\cmsis_nn.lib" ".\prebuilt\lib\cmsis_dsp.lib"
  group Source Group 1
    ./src/: quantized_multiplier_stub.cpp error_reporter_stub.cpp digit_model.c digit_recognizer.cpp
    ./src/drivers/: drv_lcd.c drv_spi0_manual.c drv_touch.c
    ./src/ui/: lcd_draw.c ui_state_machine.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c audio_capture.c audio_features.c audio_capture.h audio_features.h
    ./src/net/: cloud_asr_client.c w800_at.c cloud_asr_client.h cloud_asr_cfg.h w800_at.h
  group BSP
    ./ra/fsp/src/bsp/cmsis/Device/RENESAS/Source/: startup.c system.c
    ./ra/fsp/src/bsp/mcu/all/: bsp_clocks.c bsp_common.c bsp_delay.c bsp_guard.c bsp_group_irq.c bsp_io.c bsp_ipc.c bsp_irq.c bsp_macl.c bsp_ospi_b.c bsp_register_protection.c bsp_sbrk.c bsp_sdram.c bsp_security.c
    ./ra/fsp/src/bsp/mcu/ra6m5/: bsp_linker.c
    ./ra_gen/: common_data.c hal_data.c main.c pin_data.c vector_data.c
    ./ra/fsp/src/r_dtc/: r_dtc.c
    ./ra/fsp/src/r_gpt/: r_gpt.c
    ./ra/fsp/src/r_ioport/: r_ioport.c
    ./ra/fsp/src/r_sci_i2c/: r_sci_i2c.c
    ./ra/fsp/src/r_sci_uart/: r_sci_uart.c
    ./ra/fsp/src/r_ssi/: r_ssi.c
